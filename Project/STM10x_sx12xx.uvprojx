# Keil uVision project STM10x_sx12xx.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Show_Control +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o Show_Control.bin ./Objects/Show_Control.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, STM32F10X=1,USE_STDPERIPH_DRIVER,USE_SX1276_RADIO=1,PLATFORM =SX12xxEiger,LoRA_master=0
  c include: ..\Interface;..\Interface\include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Interface\include\drivers;..\Interface\include;..\Interface;..\DRIVERS;..\APP;..\DRIVERS\SX12xxDrivers\src\platform\sx12xxEiger;..\DRIVERS\SX12xxDrivers\src\radio;..\DRIVERS\SX12xxDrivers\src\platform
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c main.h stm32f10x_it.c system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group StdPerph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c
  group Interface
    ../Interface/: serial.c
    ../Interface/src/: completion.c pipe.c ringbuffer.c waitqueue.c workqueue.c dataqueue.c
    ../Interface/include/: rtdevice.h
  group drivers
    ../DRIVERS/: usart.c usart.h iwdg.c
  group Platform
    ../DRIVERS/SX12xxDrivers/src/platform/sx12xxEiger/: fifo.c sx1276-Hal.c sx12xxEiger.c
  group Radio
    ../DRIVERS/SX12xxDrivers/src/radio/: radio.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c
  group SX12XX_IOLEVEL
    ../DRIVERS/SX12xxDrivers/src/platform/sx12xxEiger/: ioe.c
software components: RTOS:device drivers 3.0.3, RTOS:kernel 3.0.3, RTOS:shell 3.0.3
